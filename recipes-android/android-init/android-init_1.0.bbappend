FILESEXTRAPATHS_prepend_nemo := "${THISDIR}/${PN}:"
