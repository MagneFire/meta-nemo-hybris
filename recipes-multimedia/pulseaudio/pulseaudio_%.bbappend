RDEPENDS_pulseaudio-server_append_nemo = "pulseaudio-modules-droid"
