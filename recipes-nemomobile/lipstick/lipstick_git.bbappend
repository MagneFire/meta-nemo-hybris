RDEPENDS_${PN}_append_nemo = " qt5-qpa-hwcomposer-plugin "
