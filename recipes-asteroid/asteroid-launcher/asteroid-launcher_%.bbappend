FILESEXTRAPATHS_prepend_nemo := "${THISDIR}/asteroid-launcher:"
SRC_URI_append_nemo = " file://default.conf"
