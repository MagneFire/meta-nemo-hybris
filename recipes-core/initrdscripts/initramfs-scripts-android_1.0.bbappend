FILESEXTRAPATHS_prepend_nemo := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_nemo = "nemo"
