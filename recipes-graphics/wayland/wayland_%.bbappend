SRC_URI_append_nemo = " file://0001-Remove-wayland-egl-which-is-distributed-by-libhybris.patch "
